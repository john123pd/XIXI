# Keil uVision project XYD.uvprojx, settings and files
target XYD (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: XYD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx
  c include: ..\cmsis;..\cmsis\Include;..\user;..\api
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ../startup/: startup_stm32f40_41xxx.s
  group cmsis
    ../cmsis/: system_stm32f4xx.c
  group user
    ../user/: main.c stm32f4xx_it.c config.c
  group api
    ../api/: delay.c key.c led.c
    ../user/: usart.c
software components: CMSIS:CORE 5.2.0
